# Keil uVision project HID_keyborad.uvproj, settings and files
target USBFS_DHID (ARM-ADS)
  device: GD32E103VB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32E10X GD32E103V_EVAL
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32E10x_Firmware_Library\CMSIS\GD\GD32E10x\Include;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_standard_peripheral\Include;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\driver\Include;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\device\core\Include;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\device\class\hid\Include;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\ustd\common;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\ustd\class\hid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: app.c gd32e10x_hw.c gd32e10x_it.c hid_keyboard_itf.c
  group CMSIS
    ../../../../../../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E10x_StdPeriph_Driver
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_standard_peripheral/Source/: gd32e10x_ctc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_usart.c
  group GD32E10x_EVAL
    ../../../../../Utilities/: gd32e103v_eval.c
  group USB_Driver
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/device/class/hid/Source/: standard_hid_core.c
  group Startup
    ../../../../../../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Doc
    ../: readme.txt
