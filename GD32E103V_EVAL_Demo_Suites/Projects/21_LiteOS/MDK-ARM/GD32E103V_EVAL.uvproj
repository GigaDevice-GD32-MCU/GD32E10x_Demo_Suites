# Keil uVision project GD32E103V_EVAL.uvproj, settings and files
target GD32E103V_EVAL (ARM-ADS)
  device: GD32E103VB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,RAM_SIZE_LEVEL_0,GD32E103V_EVAL
  c include: ..\..\..\..\GD32E10x_Firmware_Library\CMSIS;..\..\..\..\GD32E10x_Firmware_Library\CMSIS\GD\GD32E10x\Include;..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_standard_peripheral\Include;..\..\..\Utilities;..\;..\Third_Party\LiteOS\kernel\include;..\Third_Party\LiteOS\kernel\base\include;..\Third_Party\LiteOS\kernel\cmsis;..\Third_Party\LiteOS\kernel\config;..\Third_Party\LiteOS\kernel\cpu\arm\cortex-m4;..\Third_Party\LiteOS\kernel\link\keil;..\Third_Party\LiteOS\platform\GD32E103V-EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c systick.c gd32e10x_it.c
  group CMSIS
    ../../../../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E10x_Peripherals
    ../../../../GD32E10x_Firmware_Library/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group GD32E10x_EVAL
    ../../../Utilities/: gd32e103v_eval.c
  group Startup
    ../../../../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group LiteOS/Kernel
    ../Third_Party/LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Third_Party/LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Third_Party/LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../Third_Party/LiteOS/kernel/base/misc/: los_misc.c
  group LiteOS/Config
    ../Third_Party/LiteOS/kernel/config/: los_config.c
  group LiteOS/CPU/CM4
    ../Third_Party/LiteOS/kernel/cpu/arm/cortex-m4-nofpu/: los_dispatch_keil.s los_hw.c los_hw_tick.c los_hwi.c
  group LiteOS/CMSIS
    ../Third_Party/LiteOS/kernel/cmsis/: cmsis_liteos.c
  group LiteOS/Platform
    ../Third_Party/LiteOS/platform/GD32E103V-EVAL/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group Doc
    ../: readme.txt
